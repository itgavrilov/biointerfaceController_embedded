# Keil uVision project BCE_F205RBTx.uvprojx, settings and files
target BCE_F205RBTx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BCE_F205RBTx
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F205xx,USE_HAL_DRIVER,STM32F205xx
  c include: ../Inc; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Drivers/STM32F2xx_HAL_Driver/Inc; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Drivers/STM32F2xx_HAL_Driver/Inc/Legacy; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Drivers/CMSIS/Device/ST/STM32F2xx/Include; C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f205xx.s
  group Drivers/STM32F2xx_HAL_Driver
    C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Middlewares/USB_Device_Library
    C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    C:/Users/ItGavrilov/STM32Cube/Repository/STM32Cube_FW_F2_V1.8.0/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User
    ../Src/: biointerfaceControllerLib.c main.c gpio.c adc.c dma.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f2xx_it.c stm32f2xx_hal_msp.c
software components: CMSIS:CORE 4.3.0
